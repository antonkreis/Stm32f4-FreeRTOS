# Keil uVision project FreeRTOS_Project2.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOS_Project2
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\FreeRTOS;.\FreeRTOS\include;.\FreeRTOS\portable;.\FreeRTOS\portable\MemMang;.\FreeRTOS\portable\GCC;.\FreeRTOS\portable\GCC\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/portable/MemMang/: heap_2.c
    ./FreeRTOS/portable/GCC/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0, CMSIS:NN Lib 1.3.0, Device:Startup 2.6.3
